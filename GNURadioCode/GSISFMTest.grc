<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>GSISFMTEST</value></param>
<param><key>author</key><value>Braedon Bellamy</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Ground station integration software FM Test Code</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>sat</value></param>
<param><key>value</key><value>98.5</value></param>
<param><key>gui_hint</key><value>settingsTab:</value></param>
<param><key>label0</key><value>98.5</value></param>
<param><key>label1</key><value>106.7</value></param>
<param><key>label2</key><value>97.9</value></param>
<param><key>label3</key><value>97.3</value></param>
<param><key>label4</key><value>105.9</value></param>
<param><key>label</key><value>Satellite</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>98.5</value></param>
<param><key>option1</key><value>106.7</value></param>
<param><key>option2</key><value>97.9</value></param>
<param><key>option3</key><value>97.3</value></param>
<param><key>option4</key><value>105.9</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>AudioSink</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>DCBlocker</value></param>
<param><key>length</key><value>1024</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>FreqSink</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>sat*1e6</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>LowPassFilter</value></param>
<param><key>cutoff_freq</key><value>10e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>2e6</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>Resampler</value></param>
<param><key>decim</key><value>8</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>WaterfallSink</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>sat*1e6</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>WavSink</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>file</key><value>/home/braedonb98/GSIS/WXTOIMGFIles/GSISSatTest</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>10</value></param>
<param><key>quad_rate</key><value>48e4</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>settingsTab</value></param>
<param><key>label0</key><value>Settings</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>300</value></param>
<param><key>center_freq0</key><value>sat*1e6</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>1</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
</block>
<connection><source_block_id>DCBlocker</source_block_id><sink_block_id>FreqSink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DCBlocker</source_block_id><sink_block_id>Resampler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DCBlocker</source_block_id><sink_block_id>WaterfallSink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>LowPassFilter</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Resampler</source_block_id><sink_block_id>LowPassFilter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>AudioSink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>WavSink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>DCBlocker</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
