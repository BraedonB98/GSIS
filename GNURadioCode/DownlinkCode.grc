options:
  parameters:
    author: Braedon Bellamy
    generate_options: qt_gui
    id: GSIS
    output_language: python
    title: Ground Station Integration Software
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: 90e6
    step: 200e3
    stop: 110e6
    value: 97.3e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: sat
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'settingsTab:'
    label: Satellite
    label0: NOAA-15
    label1: NOAA-18
    label2: NOAA-19
    num_opts: '3'
    option1: '102.7'
    option2: '106.7'
    orient: Qt.QHBoxLayout
    type: real
    value: '97.3'
    widget: radio_buttons
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 48e4
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/braedonb98/GSIS/WAVFilesFromGNURadio/Wxtoimginput.wav
    samp_rate: '48000'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e6
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bw0: '100000'
    dc_offset_mode0: '2'
    freq0: sat*1e6
    gain0: '8'
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: sat*1e6
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: sat*1e6
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: settingsTab
  id: qtgui_tab_widget
  parameters:
    label0: Settings
    num_tabs: '1'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', blocks_wavfile_sink_0, '0']
- [dc_blocker_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [dc_blocker_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [dc_blocker_xx_0, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_1, '0', dc_blocker_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_1, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
